# Keil uVision project LIB.uvprojx, settings and files
target BasicApp_ROM (6120000::V6.12::.\ARMCLANG)
  device: RX32G410 ICORE
  pack: Keil.RX32G410_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RX32G410_ROM +hex (library)
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: RX32G410,DEBUG_POWER_OUT,SimZero
  c include: ..\..\..\..\..\..\..\Drivers\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\..\Drivers\CMSIS\CM4\DeviceSupport\inc;..\..\..\..\..\..\..\Drivers\RX32G4xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Middlewares\System\inc;..\..\API\inc;..\..\APP\POWER\inc;..\..\APP\sys\inc;..\..\BaseClass\inc;..\..\DRV\INC;..\..\INTERFACE\inc;..\..\Users\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../../../../../../../Drivers/CMSIS/CM4/DeviceSupport/src/: system_rx32g4xx.c
  group Startup
    ../../../../../../../Drivers/Startup/Keil/: startup_rx32g410.s
  group Middlewares
    ../../../../../../../Middlewares/System/src/: system_bsp.c system_init.c
  group Drivers\HAL
    ../../../../../../../Drivers/RX32G4xx_HAL_Driver/Src/: rx32g4xx_hal.c rx32g4xx_hal_adc.c rx32g4xx_hal_adc_ex.c rx32g4xx_hal_can.c rx32g4xx_hal_clc.c rx32g4xx_hal_comp.c rx32g4xx_hal_cordic.c rx32g4xx_hal_cortex.c rx32g4xx_hal_crc.c rx32g4xx_hal_dac.c rx32g4xx_hal_dac_ex.c rx32g4xx_hal_dma.c rx32g4xx_hal_dma_ex.c rx32g4xx_hal_exti.c rx32g4xx_hal_flash.c rx32g4xx_hal_flash_ex.c rx32g4xx_hal_fmac.c rx32g4xx_hal_gpio.c rx32g4xx_hal_hrtim.c rx32g4xx_hal_i2c.c rx32g4xx_hal_iwdg.c rx32g4xx_hal_opamp.c rx32g4xx_hal_opamp_ex.c rx32g4xx_hal_pwr.c rx32g4xx_hal_pwr_ex.c rx32g4xx_hal_rcc.c rx32g4xx_hal_rcc_ex.c rx32g4xx_hal_rtc.c rx32g4xx_hal_rtc_ex.c rx32g4xx_hal_spi.c rx32g4xx_hal_tim.c rx32g4xx_hal_tim_ex.c rx32g4xx_hal_wwdg.c rx32g4xx_hal_uart.c
  group DRV
    ../../DRV/SRC/: DRV_GPIO.C adc_processing.s adc_processing1.c drv_hrtim.c
  group APP/SYS
    ../../APP/sys/SRC/: S_PID.C s_time_base.c Simulative_Uart.c sys_task.c
  group APP/POWER
    ../../APP/POWER/src/: app_task.c APP_ZERO.C APP_ADC.C app_power.c app_power_drv.c
  group INTERFACE
    ../../INTERFACE/src/: Proto_SlaveI2C.C
  group API
    ../../API/src/: API_adc.c API_comp.c API_gpio.c API_hrtim.c API_TIM.C API_I2C.C API_OPAM.C API_DMA.C API_DAC.C
  group baseClass
    ../../BaseClass/src/: CommClass.c
  group USER
    ../../Users/src/: rx32g4xx_it.c main.c
  group output
    ./: rx410.sct
    ./Output_ROM/Objects/: RX32G410_ROM.sct
