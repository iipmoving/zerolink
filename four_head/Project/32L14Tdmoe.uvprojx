# Keil uVision project 32L14Tdmoe.uvprojx, settings and files
target 32L14Tdmoe (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SC32L14TR8 SinOneMicroelectronics
  pack: SinOne.SC32F1xxx_DFP.1.1.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HL-4IH—DSX06B +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SC32L14xx
  c include: ..\src\vendor\FWLib\SC32F1XXX_Lib\inc;..\src\vendor\CMSIS;..\src\vendor\MCU_Drivers;..\src\app;..\src;..\src\hal;..\src\drv;..\src\proto;..\src\cfg;..\src\core
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group FWLib
    ../src/vendor/FWLib/SC32F1XXX_Lib/src/: sc32f1xxx_iap.c sc32f1xxx_crc.c sc32f1xxx_wdt.c sc32f1xxx_btm.c sc32f1xxx_adc.c sc32f1xxx_tim.c sc32f1xxx_rcc.c sc32f1xxx_uart.c sc32f1xxx_option.c sc32f1xxx_gpio.c sc32f1xxx_temper.c sc32f1xxx_twi.c sc32f1xxx_dma.c
  group Startup
    ./: startup_sc32L14xx.s
  group hal
    ../src/hal/: hal_gpio.c hal_timer.c hal_uart.c hal_key.c hal_comm.c hal_display.c hal_buzzer.c hal_smg.c
  group src
    ../src/: main.c
    ../src/core/: data_switcher.c
  group app
    ../src/app/: app_comm_mgr.c app_protect.c app_power.c app_cooking.c app_hmi.c app_seg_align.c
  group lib
    ../src/vendor/lib/: system_sc32f1xxx.c SC_TK_Scan.c SMG_Disp_General_Lib_1.5.lib
    ../src/vendor/MCU_Drivers/SOC_DebugTouchKey_Lib/: SC32L14xx_DynamicDebug_V0.1.lib
    ../src/vendor/MCU_Drivers/TKDriverNew/: SC_M0+_HighSensitive_lib_Basic_V1.0.lib SC_M0+_HighSensitive_lib_T1_V1.0.lib TKDriver.c
  group drv
    ../src/drv/: drv_key.c drv_display.c drv_buzzer.c drv_comm_mgr.c drv_comm.c
  group proto
    ../src/proto/: proto_modbus.c proto_modbus_module.c
  group cfg
    ../src/cfg/: hmi_data.c
